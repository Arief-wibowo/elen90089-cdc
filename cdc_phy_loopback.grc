options:
  parameters:
    copyright: University of Melbourne
    generate_options: qt_gui
    id: cdc_phy_loopback
    output_language: python
    title: CDC PHY Loopback
  states: {}

blocks:
- name: amp_gain
  id: variable_qtgui_range
  parameters:
    label: Amp Gain
    start: '-3'
    step: '0.1'
    stop: '3'
    value: '0.0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: nbytes
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_rot
  id: variable_qtgui_range
  parameters:
    label: Phase Rot
    start: '-np.pi'
    step: 2*np.pi/200
    stop: np.pi
    value: np.pi/4
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(nbytes, 0x00))
    period: '500'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: cdc_insert_burst_c_0
  id: cdc_insert_burst_c
  parameters: {}
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.001'
    seed: '0'
    taps: np.exp(1j*phase_rot)*10**(amp_gain)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: phy_rx_0
  id: phy_rx
  parameters:
    excess_bw: excess_bw
    sps: sps
  states: {}
- name: phy_tx_0
  id: phy_tx
  parameters:
    excess_bw: excess_bw
    phasing: '20'
    sps: sps
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2, 0, 1, 1
    name: '"Symbol Sync"'
    size: 64 + (4 + nbytes + 4)*8
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2, 1, 1, 1
    name: '"Costas Loop"'
    size: 64 + (4 + nbytes + 4)*8
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1, 0, 1, 2
    name: '"Preamble"'
    size: '256'
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: float
    ymax: '1.5'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3, 0, 1, 2
    name: '"Payload Bytes"'
    size: nbytes + 4
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '256'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0, 0, 1, 2
    name: '"AGC"'
    size: sps*(11 + 20 + 64 + (4 + nbytes + 4)*8)
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [blocks_message_strobe_1, strobe, phy_tx_0, sdu]
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [cdc_insert_burst_c_0, '0', blocks_throttle2_0, '0']
- [channels_channel_model_0, '0', phy_rx_0, '0']
- [phy_rx_0, '0', qtgui_const_sink_x_0, '0']
- [phy_rx_0, '1', qtgui_const_sink_x_0_0, '0']
- [phy_rx_0, '2', blocks_uchar_to_float_0, '0']
- [phy_rx_0, '3', qtgui_time_sink_x_0, '0']
- [phy_rx_0, '4', qtgui_time_sink_x_1, '0']
- [phy_rx_0, pdu, blocks_message_debug_0, print]
- [phy_tx_0, burst, cdc_insert_burst_c_0, burst]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
