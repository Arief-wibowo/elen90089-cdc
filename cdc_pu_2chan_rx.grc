options:
  parameters:
    copyright: University of Melbourne
    generate_options: qt_gui
    id: cdc_pu_2chan_rx
    output_language: python
    title: DSA Primary User Rx - 2 Channel
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: n_chan
  id: variable
  parameters:
    value: '2'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: reset_var
  id: variable_qtgui_push_button
  parameters:
    label: Reset Stats
    pressed: 'True'
    released: 'False'
    type: bool
    value: '0'
  states: {}
- name: rf_freq
  id: variable_qtgui_range
  parameters:
    label: RF Frequency
    start: 70e6
    step: 1e3
    stop: 6e9
    value: 915e6
    widget: counter
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain (dB)
    start: '-15'
    step: '1'
    stop: '60'
    value: '30'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, 0j, 0j, 0j, 0j]'
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    bw: '0'
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: '0'
    fpga_image: ''
    fpga_reload: 'False'
    freq: rf_freq
    gain0: rx_gain
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '0'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_rate: n_chan*samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: '0'
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: warning
    xb200: none
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: cdc_dsa_stats_0
  id: cdc_dsa_stats
  parameters:
    period: ' 1'
    primary: 'True'
    reset: reset_var
    tput_offered: '0.0'
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: '"packet_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: digital_ofdm_rx_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: '"packet_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: samp_rate/2
    decim: n_chan
    nthreads: '4'
    samp_rate: n_chan*samp_rate
    taps: filter.firdes.low_pass(1, n_chan*samp_rate, 0.49e6, 0.1e6)
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-samp_rate/2'
    decim: n_chan
    nthreads: '4'
    samp_rate: n_chan*samp_rate
    taps: filter.firdes.low_pass(1, n_chan*samp_rate, 0.49e6, 0.1e6)
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: rf_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    timeout: '100'
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:95000
    timeout: '100'
    type: complex
  states: {}

connections:
- [bladeRF_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [bladeRF_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [bladeRF_source_0, '0', qtgui_freq_sink_x_0, '0']
- [cdc_dsa_stats_0, stats, blocks_message_debug_0, print]
- [digital_ofdm_rx_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_ofdm_rx_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', digital_ofdm_rx_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', digital_ofdm_rx_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, cdc_dsa_stats_0, pdu]
- [pdu_tagged_stream_to_pdu_0_0, pdus, cdc_dsa_stats_0, pdu]
- [zeromq_sub_msg_source_0, out, cdc_dsa_stats_0, stats_in]
- [zeromq_sub_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [zeromq_sub_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
