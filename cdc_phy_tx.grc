options:
  parameters:
    category: '[CDC]'
    copyright: University of Melbourne
    generate_options: hb
    id: cdc_phy_tx_mod
    output_language: python
    title: CDC PHY Tx (Mod)
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: digital.packet_utils.default_access_code
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: header_format
  id: variable
  parameters:
    value: digital.header_format_default(access_code, 0, constel.bits_per_symbol())
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: 11*sps
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: constel.bits_per_symbol()
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: digital_additive_scrambler_bb_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'True'
    length_tag_name: '"packet_len"'
    post_padding: num_taps//2
    pre_padding: '0'
    type: complex
    window: firdes.window(window.WIN_HANN, phasing, 0)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: constel.points()
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: header_format
    len_tag_key: '"packet_len"'
  states: {}
- name: excess_bw
  id: parameter
  parameters:
    label: Excess Bw
    type: eng_float
    value: '0.350'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: burst
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: symbols
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: sdu
    optional: 'True'
    type: message
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: phasing
  id: parameter
  parameters:
    label: Phasing Symbols
    type: intx
    value: '20'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    gain: '1.0'
    interp: sps
    ntaps: num_taps
    samp_rate: sps
    sym_rate: '1.0'
    type: interp_fir_filter_ccf
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samps per Symb
    type: intx
    value: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_bytes
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_bytes
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0, '0']
- [digital_additive_scrambler_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_additive_scrambler_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_burst_shaper_xx_0, '0', root_raised_cosine_filter_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', digital_burst_shaper_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', pad_sink_1_0, '0']
- [digital_crc_append_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [pad_source_0, out, digital_crc_append_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', digital_additive_scrambler_bb_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, pad_sink_0, in]
- [root_raised_cosine_filter_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [virtual_source_0, '0', blocks_repack_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
