options:
  parameters:
    generate_options: qt_gui
    id: cdc_phy_plutoSDR
    output_language: python
    title: CDC plutoSDR Loopback
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: nbytes
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 1, 1, 1
    label: Rx Gain (dB)
    start: '0.0'
    step: '1'
    stop: '66.0'
    value: '30.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 1
    label: Tx Atten (dB)
    start: '0.0'
    step: '0.25'
    stop: '89.75'
    value: '10.0'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(nbytes, 0x00))
    period: '500'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: cdc_insert_burst_c_0
  id: cdc_insert_burst_c
  parameters: {}
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(rf_freq)
    samplerate: int(samp_rate)
    type: fc32
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(rf_freq)
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
  states: {}
- name: phy_rx_0
  id: phy_rx
  parameters:
    excess_bw: excess_bw
    sps: sps
  states: {}
- name: phy_tx_0
  id: phy_tx
  parameters:
    excess_bw: excess_bw
    phasing: '20'
    sps: sps
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 3, 0, 1, 1
    name: '"Symbol Sync"'
    size: 64 + (4 + nbytes + 4)*8
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 3, 1, 1, 1
    name: '"Costas Loop"'
    size: 64 + (4 + nbytes + 4)*8
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2, 0, 1, 2
    name: '"Preamble Correlation"'
    size: '256'
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: float
    ymax: '1.5'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4, 0, 1, 2
    name: '"Payload Bytes"'
    size: nbytes + 4
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '256'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1, 0, 1, 2
    name: '"AGC"'
    size: sps*(11 + 20 + 64 + (4 + nbytes +4)*8)
    srate: samp_rate
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
  states: {}

connections:
- [blocks_message_strobe_0, strobe, phy_tx_0, sdu]
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [cdc_insert_burst_c_0, '0', iio_pluto_sink_0, '0']
- [iio_pluto_source_0, '0', phy_rx_0, '0']
- [phy_rx_0, '0', qtgui_const_sink_x_0_0, '0']
- [phy_rx_0, '1', qtgui_const_sink_x_0_0_0, '0']
- [phy_rx_0, '2', blocks_uchar_to_float_0, '0']
- [phy_rx_0, '3', qtgui_time_sink_x_0, '0']
- [phy_rx_0, '4', qtgui_time_sink_x_2, '0']
- [phy_rx_0, pdu, blocks_message_debug_0, print]
- [phy_tx_0, burst, cdc_insert_burst_c_0, burst]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
